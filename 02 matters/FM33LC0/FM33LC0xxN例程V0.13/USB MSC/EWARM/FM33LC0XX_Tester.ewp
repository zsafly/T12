# IAR project FM33LC0XX_Tester.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: FM33LC04x FMSH FM33LC04x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: FM33LC0XX; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS\Inculde; ..\Drivers\FM33LC0xx_LL_Driver\Inc; ..\Drivers\CMSIS\Device\FM\FM33xx\Include; ..\MF-config\Inc; ..\Inc; ..\Middleware\USB\App\inc; ..\Middleware\USB\Core\inc; ..\Middleware\USB\Device\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: FM33LC0XX; USE_FULL_ASSERT
  AARM.AUserIncludes: ..\Drivers\CMSIS\Inculde; ..\Drivers\FM33LC0xx_LL_Driver\Inc; ..\Drivers\CMSIS\Device\FM\FM33xx\Include; ..\MF-config\Inc; ..\Inc
  OBJCOPY.OOCOutputFile: FM33LC0XX_Tester.hex
  ILINK.IlinkOutputFile: FM33LC0XX_Tester.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\FMSH\FM33LC04x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Example/Application/EWARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/iar/: startup_fm33lc0xx.s
  group Example/Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Example/Application/User
    ../Src/: main.c usb.c user_init.c
  group Example/Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33lc0xx.c
  group Example/Drivers/FM33LC0xx_LL_Driver
    ../Drivers/FM33LC0xx_LL_Driver/Src/: fm33lc0xx_ll_adc.c fm33lc0xx_ll_aes.c fm33lc0xx_ll_atim.c fm33lc0xx_ll_bstim.c fm33lc0xx_ll_comp.c fm33lc0xx_ll_crc.c fm33lc0xx_ll_dma.c fm33lc0xx_ll_flash.c fm33lc0xx_ll_gpio.c fm33lc0xx_ll_gptim.c fm33lc0xx_ll_hdiv.c fm33lc0xx_ll_i2c.c fm33lc0xx_ll_iwdt.c fm33lc0xx_ll_lcd.c fm33lc0xx_ll_lptim.c fm33lc0xx_ll_lpuart.c fm33lc0xx_ll_opa.c fm33lc0xx_ll_pmu.c fm33lc0xx_ll_rcc.c fm33lc0xx_ll_rng.c fm33lc0xx_ll_rtc.c fm33lc0xx_ll_spi.c fm33lc0xx_ll_svd.c fm33lc0xx_ll_u7816.c fm33lc0xx_ll_uart.c fm33lc0xx_ll_wwdt.c
  group Example/USB/App
    ../Middleware/USB/App/src/: msc_bot.c msc_core.c msc_data.c msc_mem.c msc_scsi.c usb_bsp.c usbd_desc.c usbd_usr.c
  group Example/USB/Core
    ../Middleware/USB/Core/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group Example/USB/Device
    ../Middleware/USB/Device/src/: usbd_core.c usbd_ioreq.c usbd_req.c
