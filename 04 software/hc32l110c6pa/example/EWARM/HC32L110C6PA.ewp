# IAR project HC32L110C6PA.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: HC32L110C6PA HDSC HC32L110C6PA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32l110c6pa.srec
  ILINK.IlinkOutputFile: hc32l110c6pa.out
  ILINK.IlinkIcfFile: config\hc32l110c6pa.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  group common
    ./: startup_hc32l110c6pa.s
    ../../common/: system_hc32l110c6pa.c
  group source
    ../source/: main.c
